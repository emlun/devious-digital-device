File: midnight-sun-2019/led-matrix.sch (KiCad schematic (older format))
At the start: 476 parts

Commit message: Swap positions of LEDs and Rs in matrix
Connections:
- net GND: now also D201.1 (K), D202.1 (K), D203.1 (K), D204.1 (K), D205.1 (K), D206.1 (K), D207.1 (K), D208.1 (K), D209.1 (K), D210.1 (K), D211.1 (K), D212.1 (K)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; no longer R201.1, R202.1, R203.1, R204.1, R205.1, R206.1, R207.1, R208.1, R209.1, R210.1, R211.1, R212.1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
- net a0: now also R201.2; no longer D201.2 (A), D202.2 (A), D203.2 (A), D204.2 (A), D205.2 (A), D206.2 (A), D207.2 (A), D208.2 (A), D209.2 (A), D210.2 (A), D211.2 (A), D212.2 (A)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
- net a1: now also R202.2; no longer D234.2 (A), D235.2 (A), D236.2 (A), D237.2 (A), D238.2 (A), D239.2 (A), D240.2 (A), D241.2 (A), D242.2 (A), D243.2 (A), D244.2 (A), D245.2 (A)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
- net a2: now also R203.2; no longer D267.2 (A), D268.2 (A), D269.2 (A), D270.2 (A), D271.2 (A), D272.2 (A), D273.2 (A), D274.2 (A), D275.2 (A), D276.2 (A), D277.2 (A), D278.2 (A)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
- net b0: now also R204.2; no longer D300.2 (A), D301.2 (A), D302.2 (A)
- net b1: now also R205.2; no longer D303.2 (A), D304.2 (A), D305.2 (A)
- net b10: now also R214.2; no longer D330.2 (A), D331.2 (A), D332.2 (A)
- net b11: now also R215.2; no longer D333.2 (A), D334.2 (A), D335.2 (A)
- net b12: now also R216.2; no longer D336.2 (A), D337.2 (A), D338.2 (A)
- net b13: now also R217.2; no longer D339.2 (A), D340.2 (A), D341.2 (A)
- net b14: now also R218.2; no longer D342.2 (A), D343.2 (A), D344.2 (A)
- net b15: now also R219.2; no longer D345.2 (A), D346.2 (A), D347.2 (A)
- net b2: now also R206.2; no longer D306.2 (A), D307.2 (A), D308.2 (A)
- net b3: now also R207.2; no longer D309.2 (A), D310.2 (A), D311.2 (A)
- net b4: now also R208.2; no longer D312.2 (A), D313.2 (A), D314.2 (A)
- net b5: now also R209.2; no longer D315.2 (A), D316.2 (A), D317.2 (A)
- net b6: now also R210.2; no longer D318.2 (A), D319.2 (A), D320.2 (A)
- net b7: now also R211.2; no longer D321.2 (A), D322.2 (A), D323.2 (A)
- net b8: now also R212.2; no longer D324.2 (A), D325.2 (A), D326.2 (A)
- net b9: now also R213.2; no longer D327.2 (A), D328.2 (A), D329.2 (A)
- net o0: now also R228.2; no longer D519.2 (A), D520.2 (A), D521.2 (A), D522.2 (A), D523.2 (A), D524.2 (A), D525.2 (A), D526.2 (A), D527.2 (A), D528.2 (A), D529.2 (A), D530.2 (A)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
- net o1: now also R229.2; no longer D535.2 (A), D536.2 (A), D537.2 (A), D538.2 (A), D539.2 (A), D540.2 (A), D541.2 (A), D542.2 (A), D543.2 (A), D544.2 (A), D545.2 (A), D546.2 (A)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
- net o2: now also R230.2; no longer D551.2 (A), D552.2 (A), D553.2 (A), D554.2 (A), D555.2 (A), D556.2 (A), D557.2 (A), D558.2 (A), D559.2 (A), D560.2 (A), D561.2 (A), D562.2 (A)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
- net o3: now also R231.2; no longer D567.2 (A), D568.2 (A), D569.2 (A), D570.2 (A), D571.2 (A), D572.2 (A), D573.2 (A), D574.2 (A), D575.2 (A), D576.2 (A), D577.2 (A), D578.2 (A)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
- net o4: now also R232.2; no longer D582.2 (A), D583.2 (A), D584.2 (A), D585.2 (A), D586.2 (A), D587.2 (A), D588.2 (A), D589.2 (A), D590.2 (A), D591.2 (A), D592.2 (A), D593.2 (A)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
- net o5: now also R233.2; no longer D597.2 (A), D598.2 (A), D599.2 (A), D600.2 (A), D601.2 (A), D602.2 (A), D603.2 (A), D604.2 (A), D605.2 (A), D606.2 (A), D607.2 (A), D608.2 (A)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
- net o6: now also R234.2; no longer D612.2 (A), D613.2 (A), D614.2 (A), D615.2 (A), D616.2 (A), D617.2 (A), D618.2 (A), D619.2 (A), D620.2 (A), D621.2 (A), D622.2 (A), D623.2 (A)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
- net o7: now also R235.2; no longer D627.2 (A), D628.2 (A), D629.2 (A), D630.2 (A), D631.2 (A), D632.2 (A), D633.2 (A), D634.2 (A), D635.2 (A), D636.2 (A), D637.2 (A), D638.2 (A)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
- net z0: now also R220.2; no longer D348.2 (A), D349.2 (A), D350.2 (A), D351.2 (A), D352.2 (A), D353.2 (A), D354.2 (A), D355.2 (A), D356.2 (A), D357.2 (A), D358.2 (A), D359.2 (A)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
- net z1: now also R221.2; no longer D370.2 (A), D371.2 (A), D372.2 (A), D373.2 (A), D374.2 (A), D375.2 (A), D376.2 (A), D377.2 (A), D378.2 (A), D379.2 (A), D380.2 (A), D381.2 (A)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
- net z2: now also R222.2; no longer D392.2 (A), D393.2 (A), D394.2 (A), D395.2 (A), D396.2 (A), D397.2 (A), D398.2 (A), D399.2 (A), D400.2 (A), D401.2 (A), D402.2 (A), D403.2 (A)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
- net z3: now also R223.2; no longer D414.2 (A), D415.2 (A), D416.2 (A), D417.2 (A), D418.2 (A), D419.2 (A), D420.2 (A), D421.2 (A), D422.2 (A), D423.2 (A), D424.2 (A), D425.2 (A)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
- net z4: now also R224.2; no longer D435.2 (A), D436.2 (A), D437.2 (A), D438.2 (A), D439.2 (A), D440.2 (A), D441.2 (A), D442.2 (A), D443.2 (A), D444.2 (A), D445.2 (A), D446.2 (A)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
- net z5: now also R225.2; no longer D456.2 (A), D457.2 (A), D458.2 (A), D459.2 (A), D460.2 (A), D461.2 (A), D462.2 (A), D463.2 (A), D464.2 (A), D465.2 (A), D466.2 (A), D467.2 (A)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
- net z6: now also R226.2; no longer D477.2 (A), D478.2 (A), D479.2 (A), D480.2 (A), D481.2 (A), D482.2 (A), D483.2 (A), D484.2 (A), D485.2 (A), D486.2 (A), D487.2 (A), D488.2 (A)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
- net z7: now also R227.2; no longer D498.2 (A), D499.2 (A), D500.2 (A), D501.2 (A), D502.2 (A), D503.2 (A), D504.2 (A), D505.2 (A), D506.2 (A), D507.2 (A), D508.2 (A), D509.2 (A)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
- new net: D336.2 (A), D337.2 (A), D338.2 (A), R216.1
- new net: D339.2 (A), D340.2 (A), D341.2 (A), R217.1
- new net: D342.2 (A), D343.2 (A), D344.2 (A), R218.1
- new net: D345.2 (A), D346.2 (A), D347.2 (A), R219.1
- new net: D324.2 (A), D325.2 (A), D326.2 (A), R212.1
- new net: D327.2 (A), D328.2 (A), D329.2 (A), R213.1
- new net: D330.2 (A), D331.2 (A), D332.2 (A), R214.1
- new net: D333.2 (A), D334.2 (A), D335.2 (A), R215.1
- new net: D348.2 (A), D349.2 (A), D350.2 (A), D351.2 (A), D352.2 (A), D353.2 (A), D354.2 (A), D355.2 (A), D356.2 (A), D357.2 (A), D358.2 (A), D359.2 (A)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
- new net: D370.2 (A), D371.2 (A), D372.2 (A), D373.2 (A), D374.2 (A), D375.2 (A), D376.2 (A), D377.2 (A), D378.2 (A), D379.2 (A), D380.2 (A), D381.2 (A)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
Other:
- moved on the sheet: D201, D202, D203, D204, D205, D206, D207, D208, D209, D210, D211, D212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

Commit message: Add GND wires to LED matrix
Changed lines of the file:
@@
 Connection ~ 2550 1400
 Connection ~ 2550 800
-Connection ~ 1050 800
 Wire Wire Line
 	950  800  1050 800
@@
 Wire Wire Line
 	1050 1000 1050 1100
-Connection ~ 1050 1000
-Wire Wire Line
-	1050 900  1050 1000
-Connection ~ 1050 900
-Wire Wire Line
-	1050 800  1050 900
-Wire Wire Line
-	1350 800  1350 900
-Connection ~ 1350 900
 $Comp
 L Device:LED D?
@@
 	-1   0    0    1
 $EndComp
-$Comp
-L Device:LED D?
-U 1 1 61C56D7B
-P 1200 800
-AR Path="/61C56D7B" Ref="D?"  Part="1"
-AR Path="/61AF721F/61C56D7B" Ref="D201"  Part="1"
-F 0 "D201" H 1193 545 50  0000 C CNN
-F 1 "LED" H 1193 636 50  0000 C CNN
-F 2 "LED_SMD:LED_0805_2012Metric_Castellated" H 1200 800 50  0001 C CNN
-F 3 "~" H 1200 800 50  0001 C CNN
-	1    1200 800
-	-1   0    0    1
-$EndComp
 Connection ~ 1350 1100
 Wire Wire Line
@@
 	-1   0    0    1
 $EndComp
-Wire Wire Line
-	1350 900  1350 1000
-Connection ~ 1350 1000
-$Comp
-L Device:LED D?
-U 1 1 61C56D5A
-P 1200 1000
-AR Path="/61C56D5A" Ref="D?"  Part="1"
-AR Path="/61AF721F/61C56D5A" Ref="D203"  Part="1"
-F 0 "D203" H 1193 745 50  0000 C CNN
-F 1 "LED" H 1193 836 50  0000 C CNN
-F 2 "LED_SMD:LED_0805_2012Metric_Castellated" H 1200 1000 50  0001 C CNN
-F 3 "~" H 1200 1000 50  0001 C CNN
-	1    1200 1000
-	-1   0    0    1
-$EndComp
 Connection ~ 1350 1300
 Wire Wire Line
@@
 	-1   0    0    1
 $EndComp
-Connection ~ 1350 800
 Connection ~ 1050 4350
 Connection ~ 1350 4350
@@
 Connection ~ 7450 5500
 Connection ~ 7450 7850
+$Comp
+L Device:LED D?
+U 1 1 61C56D5A
+P 1200 1000
+AR Path="/61C56D5A" Ref="D?"  Part="1"
+AR Path="/61AF721F/61C56D5A" Ref="D203"  Part="1"
+F 0 "D203" H 1193 745 50  0000 C CNN
+F 1 "LED" H 1193 836 50  0000 C CNN
+F 2 "LED_SMD:LED_0805_2012Metric_Castellated" H 1200 1000 50  0001 C CNN
+F 3 "~" H 1200 1000 50  0001 C CNN
+	1    1200 1000
+	-1   0    0    1
+$EndComp
+$Comp
+L Device:LED D?
+U 1 1 61C56D7B
+P 1200 800
+AR Path="/61C56D7B" Ref="D?"  Part="1"
+AR Path="/61AF721F/61C56D7B" Ref="D201"  Part="1"
+F 0 "D201" H 1193 545 50  0000 C CNN
+F 1 "LED" H 1193 636 50  0000 C CNN
+F 2 "LED_SMD:LED_0805_2012Metric_Castellated" H 1200 800 50  0001 C CNN
+F 3 "~" H 1200 800 50  0001 C CNN
+	1    1200 800
+	-1   0    0    1
+$EndComp
+Wire Wire Line
+	1050 800  1050 900
+Connection ~ 1050 800
+Wire Wire Line
+	1050 900  1050 1000
+Connection ~ 1050 900
+Connection ~ 1050 1000
+Wire Wire Line
+	1350 1000 1350 900
+Connection ~ 1350 1000
+Wire Wire Line
+	1350 900  1350 800
+Connection ~ 1350 900
+Connection ~ 1350 800
 $EndSCHEMATC
