File: midnight-sun-2019/led-matrix.sch (KiCad schematic (older format))
At the start: 476 parts

Commit message: Update PCB routes to agree with new schematic
Parts:
- renumbered R26 to R27, R27 to R28, R28 to R29, R29 to R30, R30 to R31, R31 to R32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
