# Repository emlun/devious-digital-device

File README.md:

"Devious Digital Device" challenge for Midnight Sun CTF 2019
---

This repository contains the scripts and schematics used to create the "Devious
Digital Device" challenge for [Midnight Sun CTF][midnight-sun] 2019. A
walkthrough of the design and development of the project can be found
[here][build-log].

`exploration/explore.m` can be run in [Octave][octave] or [MATLAB][matlab]. The
`midnight-sun-2019` directory can be opened as a project in [KiCad][kicad]. All
necessary resources should be included in the project or the KiCAD standard
distribution; if they're not, please file a bug.

All files in this repository are licensed under a [Creative Commons
Attribution 4.0 International License][cc] unless noted otherwise.

[build-log]: https://emlun.se/2019/08/02/design-devious-digital-device-midnight-sun-ctf-2019.html
[cc]: https://creativecommons.org/licenses/by/4.0/
[kicad]: http://kicad-pcb.org/
[matlab]: https://www.mathworks.com/products/matlab.html
[midnight-sun]: https://www.midnightsunctf.se/
[octave]: https://www.gnu.org/software/octave/

## KiCad design midnight-sun-2019/midnight-sun-2019.kicad_pcb

Parts:
BT1, BT2: Battery_Cell; BatteryHolder_CR2016_CR2025_CR2032_22mm
C1: 100 nF; C_Disc_D7.5mm_W2.5mm_P5.00mm
C2, C3, C4: 10 uF; CP_Radial_D5.0mm_P2.00mm
D1, D3: LED; LED_D5.0mm
D2: LED; LED_D5.0mm_Clear
D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20: LED; LED_0805_2012Metric_Castellated_no_silkscreen
J1: Conn_02x02_Odd_Even; PinHeader_2x02_P2.54mm_Vertical
J2: USB_B_Micro; USB_Micro-B_Electrokit_anr41011019
R1, R2, R3: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4, R5, R6: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26: R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder_no_silkscreen
SW1: SW_SPDT; SW_SPDT_MTS-102-A2
SW2, SW3: SW_SPDT; SW_PUSH_DPDT_CW_Industries_GPBS850L
U1, U9, U10, U15, U16: 74HC14; DIP-14_W7.62mm_Socket
U2, U3, U4: 74HC595; DIP-16_W7.62mm_Socket
U5, U6, U7, U8, U11, U12, U13, U14: 74HC86; DIP-14_W7.62mm_Socket

Connections:
/a0: U5.6; also elsewhere on the board
/a1: U7.11; also elsewhere on the board
/a2: U10.6; also elsewhere on the board
/b0: U9.2; also elsewhere on the board
/b1: U9.4; also elsewhere on the board
/b2: U9.6; also elsewhere on the board
/b3: U9.8; also elsewhere on the board
/b4: U9.10; also elsewhere on the board
/b5: U9.12; also elsewhere on the board
/b6: U10.2; also elsewhere on the board
/b7: U10.4; also elsewhere on the board
/b8: D7.2 (A), U3.2 (QC), U6.4, U12.9, U14.9; also elsewhere on the board
/b9: D9.2 (A), U3.4 (QE), U6.9, U11.9, U13.1; also elsewhere on the board
/b10: D10.2 (A), U3.5 (QF), U6.10, U14.4; also elsewhere on the board
/b11: D11.2 (A), U3.6 (QG), U7.1, U12.12; also elsewhere on the board
/b12: D13.2 (A), U4.15 (QA), U7.4, U11.1, U11.12, U12.1, U13.9; also elsewhere on the board
/b13: D14.2 (A), U4.1 (QB), U8.1, U14.1; also elsewhere on the board
/b14: D18.2 (A), U4.5 (QF), U8.4, U11.4, U13.12, U14.12; also elsewhere on the board
/b15: D19.2 (A), U4.6 (QG), U8.5, U12.4, U13.4; also elsewhere on the board
/clk: D2.2 (A), U1.12, U2.11 (SRCLK), U2.12 (RCLK), U3.11 (SRCLK), U3.12 (RCLK), U4.11 (SRCLK), U4.12 (RCLK)
/f0: U2.15 (QA), U5.9
/f1: U2.1 (QB), U5.12
/f6: U2.6 (QG), U5.10
/f7: U2.7 (QH), U5.13
/h0: D5.2 (A), U3.15 (QA), U6.1, U9.1, U14.5
/h1: D6.2 (A), U3.1 (QB), U6.2, U9.3, U12.10, U12.13
/h2: D8.2 (A), U3.3 (QD), U6.5, U9.5
/h3: D12.2 (A), U3.7 (QH), U7.2, U9.9, U11.5, U12.2, U13.10, U14.13
/h4: D15.2 (A), U4.2 (QC), U7.5, U9.11, U13.5, U13.13, U14.2
/h5: D16.2 (A), U4.3 (QD), U7.13, U9.13, U11.2
/h6: D17.2 (A), U4.4 (QE), U8.2, U10.1, U11.10, U12.5, U13.2
/h7: D20.2 (A), U4.7 (QH), U8.13, U10.3, U11.13, U14.10
/o0: U11.3; also elsewhere on the board
/o1: U11.6; also elsewhere on the board
/o2: U11.8; also elsewhere on the board
/o3: U11.11; also elsewhere on the board
/o4: U12.3; also elsewhere on the board
/o5: U12.6; also elsewhere on the board
/o6: U12.8; also elsewhere on the board
/o7: U12.11; also elsewhere on the board
/rst: D3.2 (A), U1.10, U2.10 (~SRCLR), U3.10 (~SRCLR), U4.10 (~SRCLR)
/usr: D1.2 (A), U1.4, U5.2
/z0: U15.12; also elsewhere on the board
/z1: U15.10; also elsewhere on the board
/z2: U15.8; also elsewhere on the board
/z3: U15.6; also elsewhere on the board
/z4: U16.12; also elsewhere on the board
/z5: U16.10; also elsewhere on the board
/z6: U16.8; also elsewhere on the board
/z7: U16.6; also elsewhere on the board
unnamed: BT1.1 (+), BT2.2 (-)
unnamed: C2.1, R1.1, U1.3
unnamed: C3.1, R2.1, U1.13
unnamed: C4.1, R3.1, U1.11
unnamed: D1.1 (K), R7.2
unnamed: D2.1 (K), R8.2
unnamed: D3.1 (K), R9.2
unnamed: D4.1 (K), R10.2
unnamed: D4.2 (A), U1.8, U2.14 (SER)
unnamed: D5.1 (K), R11.2
unnamed: D6.1 (K), R12.2
unnamed: D7.1 (K), R13.2
unnamed: D8.1 (K), R14.2
unnamed: D9.1 (K), R15.2
unnamed: D10.1 (K), R16.2
unnamed: D11.1 (K), R17.2
unnamed: D12.1 (K), R18.2
unnamed: D13.1 (K), R19.2
unnamed: D14.1 (K), R20.2
unnamed: D15.1 (K), R21.2
unnamed: D16.1 (K), R22.2
unnamed: D17.1 (K), R23.2
unnamed: D18.1 (K), R24.2
unnamed: D19.1 (K), R25.2
unnamed: D20.1 (K), R26.2
unnamed: R1.2, R4.2, SW1.2 (B)
unnamed: R2.2, R5.2, SW2.2 (B)
unnamed: R3.2, R6.2, SW3.2 (B)
unnamed: U1.9, U5.8
unnamed: U3.9 (QH'), U4.14 (SER)
unnamed: U3.14 (SER), U5.3
unnamed: U5.1, U5.11
unnamed: U5.4, U6.11
unnamed: U5.5, U6.8
unnamed: U6.3, U6.12
unnamed: U6.6, U6.13
unnamed: U7.3, U7.9
unnamed: U7.6, U7.10
unnamed: U7.8, U7.12
unnamed: U8.3, U8.9
unnamed: U8.6, U8.10
unnamed: U8.8, U8.12
unnamed: U8.11, U10.5
unnamed: U13.3, U15.13
unnamed: U13.6, U15.11
unnamed: U13.8, U15.9
unnamed: U13.11, U15.5
unnamed: U14.3, U16.13
unnamed: U14.6, U16.11
unnamed: U14.8, U16.9
unnamed: U14.11, U16.5

Parts:
D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D98, D99, D100, D101, D102, D103, D104, D105, D106, D107, D108, D109, D110, D111, D112, D113, D114, D115, D116, D117, D118, D119, D120, D121, D122, D123, D124, D125, D126, D127, D128, D129, D130, D131, D132, D133, D134, D135, D136, D137, D138, D139, D140, D141, D142, D143, D144, D145, D146, D147, D148, D149, D150, D151, D152, D153, D154, D155, D156, D157, D158, D159, D160, D161, D162, D163, D164, D165, D166, D167, D168, D169, D170, D171, D172, D173, D174, D175, D176, D177, D178, D179, D180, D181, D182, D183, D184, D185, D186, D187, D188, D189, D190, D191, D192, D193, D194, D195, D196, D197, D198, D199, D200, D201, D202, D203, D204, D205, D206, D207, D208, D209, D210, D211, D212, D213, D214, D215, D216, D217, D218, D219, D220, D221, D222, D223, D224, D225, D226, D227, D228, D229, D230, D231, D232, D233, D234, D235, D236, D237, D238, D239, D240, D241, D242, D243, D244, D245, D246, D247, D248, D249, D250, D251, D252, D253, D254, D255, D256, D257, D258, D259, D260, D261, D262, D263, D264, D265, D266, D267, D268, D269, D270, D271, D272, D273, D274, D275, D276, D277, D278, D279, D280, D281, D282, D283, D284, D285, D286, D287, D288, D289, D290, D291, D292, D293, D294, D295, D296, D297, D298, D299, D300, D301, D302, D303, D304, D305, D306, D307, D308, D309, D310, D311, D312, D313, D314, D315, D316, D317, D318, D319, D320, D321, D322, D323, D324, D325, D326, D327, D328, D329, D330, D331, D332, D333, D334, D335, D336, D337, D338, D339, D340, D341, D342, D343, D344, D345, D346, D347, D348, D349, D350, D351, D352, D353, D354, D355, D356, D357, D358, D359, D360, D361, D362, D363, D364, D365, D366, D367, D368, D369, D370, D371, D372, D373, D374, D375, D376, D377, D378, D379, D380, D381, D382, D383, D384, D385, D386, D387, D388, D389, D390, D391, D392, D393, D394, D395, D396, D397, D398, D399, D400, D401, D402, D403, D404, D405, D406, D407, D408, D409, D410, D411, D412, D413, D414, D415, D416, D417, D418, D419, D420, D421, D422, D423, D424, D425, D426, D427, D428, D429, D430, D431, D432, D433, D434, D435, D436, D437, D438, D439, D440, D441, D442, D443, D444, D445, D446, D447, D448, D449, D450, D451, D452, D453, D454, D455, D456, D457, D458, D459, D460, D461: LED; LED_0805_2012Metric_Castellated_no_silkscreen
R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61: R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Connections:
/a0: R27.2; also elsewhere on the board
/a1: R28.2; also elsewhere on the board
/a2: R29.2; also elsewhere on the board
/b0: R30.2; also elsewhere on the board
/b1: R31.2; also elsewhere on the board
/b2: R32.2; also elsewhere on the board
/b3: R33.2; also elsewhere on the board
/b4: R34.2; also elsewhere on the board
/b5: R35.2; also elsewhere on the board
/b6: R36.2; also elsewhere on the board
/b7: R37.2; also elsewhere on the board
/b8: R38.2; also elsewhere on the board
/b9: R39.2; also elsewhere on the board
/b10: R40.2; also elsewhere on the board
/b11: R41.2; also elsewhere on the board
/b12: R42.2; also elsewhere on the board
/b13: R43.2; also elsewhere on the board
/b14: R44.2; also elsewhere on the board
/b15: R45.2; also elsewhere on the board
/o0: R54.2; also elsewhere on the board
/o1: R55.2; also elsewhere on the board
/o2: R56.2; also elsewhere on the board
/o3: R57.2; also elsewhere on the board
/o4: R58.2; also elsewhere on the board
/o5: R59.2; also elsewhere on the board
/o6: R60.2; also elsewhere on the board
/o7: R61.2; also elsewhere on the board
/z0: R46.2; also elsewhere on the board
/z1: R47.2; also elsewhere on the board
/z2: R48.2; also elsewhere on the board
/z3: R49.2; also elsewhere on the board
/z4: R50.2; also elsewhere on the board
/z5: R51.2; also elsewhere on the board
/z6: R52.2; also elsewhere on the board
/z7: R53.2; also elsewhere on the board
unnamed: D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), D25.2 (A), D26.2 (A), D27.2 (A), D28.2 (A), D29.2 (A), D30.2 (A), D31.2 (A), D32.2 (A), D33.2 (A), D34.2 (A), D35.2 (A), D36.2 (A), D37.2 (A), D38.2 (A), D39.2 (A), D40.2 (A), D41.2 (A), D42.2 (A), D43.2 (A), D44.2 (A), D45.2 (A), D46.2 (A), D47.2 (A), D48.2 (A), D49.2 (A), D50.2 (A), D51.2 (A), D52.2 (A), D53.2 (A), R27.1
unnamed: D54.2 (A), D55.2 (A), D56.2 (A), D57.2 (A), D58.2 (A), D59.2 (A), D60.2 (A), D61.2 (A), D62.2 (A), D63.2 (A), D64.2 (A), D65.2 (A), D66.2 (A), D67.2 (A), D68.2 (A), D69.2 (A), D70.2 (A), D71.2 (A), D72.2 (A), D73.2 (A), D74.2 (A), D75.2 (A), D76.2 (A), D77.2 (A), D78.2 (A), D79.2 (A), D80.2 (A), D81.2 (A), D82.2 (A), D83.2 (A), D84.2 (A), D85.2 (A), D86.2 (A), R28.1
unnamed: D87.2 (A), D88.2 (A), D89.2 (A), D90.2 (A), D91.2 (A), D92.2 (A), D93.2 (A), D94.2 (A), D95.2 (A), D96.2 (A), D97.2 (A), D98.2 (A), D99.2 (A), D100.2 (A), D101.2 (A), D102.2 (A), D103.2 (A), D104.2 (A), D105.2 (A), D106.2 (A), D107.2 (A), D108.2 (A), D109.2 (A), D110.2 (A), D111.2 (A), D112.2 (A), D113.2 (A), D114.2 (A), D115.2 (A), D116.2 (A), D117.2 (A), D118.2 (A), D119.2 (A), R29.1
unnamed: D120.2 (A), D121.2 (A), D122.2 (A), R30.1
unnamed: D123.2 (A), D124.2 (A), D125.2 (A), R31.1
unnamed: D126.2 (A), D127.2 (A), D128.2 (A), R32.1
unnamed: D129.2 (A), D130.2 (A), D131.2 (A), R33.1
unnamed: D132.2 (A), D133.2 (A), D134.2 (A), R34.1
unnamed: D135.2 (A), D136.2 (A), D137.2 (A), R35.1
unnamed: D138.2 (A), D139.2 (A), D140.2 (A), R36.1
unnamed: D141.2 (A), D142.2 (A), D143.2 (A), R37.1
unnamed: D144.2 (A), D145.2 (A), D146.2 (A), R38.1
unnamed: D147.2 (A), D148.2 (A), D149.2 (A), R39.1
unnamed: D150.2 (A), D151.2 (A), D152.2 (A), R40.1
unnamed: D153.2 (A), D154.2 (A), D155.2 (A), R41.1
unnamed: D156.2 (A), D157.2 (A), D158.2 (A), R42.1
unnamed: D159.2 (A), D160.2 (A), D161.2 (A), R43.1
unnamed: D162.2 (A), D163.2 (A), D164.2 (A), R44.1
unnamed: D165.2 (A), D166.2 (A), D167.2 (A), R45.1
unnamed: D168.2 (A), D169.2 (A), D170.2 (A), D171.2 (A), D172.2 (A), D173.2 (A), D174.2 (A), D175.2 (A), D176.2 (A), D177.2 (A), D178.2 (A), D179.2 (A), D180.2 (A), D181.2 (A), D182.2 (A), D183.2 (A), D184.2 (A), D185.2 (A), D186.2 (A), D187.2 (A), D188.2 (A), D189.2 (A), R46.1
unnamed: D190.2 (A), D191.2 (A), D192.2 (A), D193.2 (A), D194.2 (A), D195.2 (A), D196.2 (A), D197.2 (A), D198.2 (A), D199.2 (A), D200.2 (A), D201.2 (A), D202.2 (A), D203.2 (A), D204.2 (A), D205.2 (A), D206.2 (A), D207.2 (A), D208.2 (A), D209.2 (A), D210.2 (A), D211.2 (A), R47.1
unnamed: D212.2 (A), D213.2 (A), D214.2 (A), D215.2 (A), D216.2 (A), D217.2 (A), D218.2 (A), D219.2 (A), D220.2 (A), D221.2 (A), D222.2 (A), D223.2 (A), D224.2 (A), D225.2 (A), D226.2 (A), D227.2 (A), D228.2 (A), D229.2 (A), D230.2 (A), D231.2 (A), D232.2 (A), D233.2 (A), R48.1
unnamed: D234.2 (A), D235.2 (A), D236.2 (A), D237.2 (A), D238.2 (A), D239.2 (A), D240.2 (A), D241.2 (A), D242.2 (A), D243.2 (A), D244.2 (A), D245.2 (A), D246.2 (A), D247.2 (A), D248.2 (A), D249.2 (A), D250.2 (A), D251.2 (A), D252.2 (A), D253.2 (A), D254.2 (A), R49.1
unnamed: D255.2 (A), D256.2 (A), D257.2 (A), D258.2 (A), D259.2 (A), D260.2 (A), D261.2 (A), D262.2 (A), D263.2 (A), D264.2 (A), D265.2 (A), D266.2 (A), D267.2 (A), D268.2 (A), D269.2 (A), D270.2 (A), D271.2 (A), D272.2 (A), D273.2 (A), D274.2 (A), D275.2 (A), R50.1
unnamed: D276.2 (A), D277.2 (A), D278.2 (A), D279.2 (A), D280.2 (A), D281.2 (A), D282.2 (A), D283.2 (A), D284.2 (A), D285.2 (A), D286.2 (A), D287.2 (A), D288.2 (A), D289.2 (A), D290.2 (A), D291.2 (A), D292.2 (A), D293.2 (A), D294.2 (A), D295.2 (A), D296.2 (A), R51.1
unnamed: D297.2 (A), D298.2 (A), D299.2 (A), D300.2 (A), D301.2 (A), D302.2 (A), D303.2 (A), D304.2 (A), D305.2 (A), D306.2 (A), D307.2 (A), D308.2 (A), D309.2 (A), D310.2 (A), D311.2 (A), D312.2 (A), D313.2 (A), D314.2 (A), D315.2 (A), D316.2 (A), D317.2 (A), R52.1
unnamed: D318.2 (A), D319.2 (A), D320.2 (A), D321.2 (A), D322.2 (A), D323.2 (A), D324.2 (A), D325.2 (A), D326.2 (A), D327.2 (A), D328.2 (A), D329.2 (A), D330.2 (A), D331.2 (A), D332.2 (A), D333.2 (A), D334.2 (A), D335.2 (A), D336.2 (A), D337.2 (A), D338.2 (A), R53.1
unnamed: D339.2 (A), D340.2 (A), D341.2 (A), D342.2 (A), D343.2 (A), D344.2 (A), D345.2 (A), D346.2 (A), D347.2 (A), D348.2 (A), D349.2 (A), D350.2 (A), D351.2 (A), D352.2 (A), D353.2 (A), D354.2 (A), R54.1
unnamed: D355.2 (A), D356.2 (A), D357.2 (A), D358.2 (A), D359.2 (A), D360.2 (A), D361.2 (A), D362.2 (A), D363.2 (A), D364.2 (A), D365.2 (A), D366.2 (A), D367.2 (A), D368.2 (A), D369.2 (A), D370.2 (A), R55.1
unnamed: D371.2 (A), D372.2 (A), D373.2 (A), D374.2 (A), D375.2 (A), D376.2 (A), D377.2 (A), D378.2 (A), D379.2 (A), D380.2 (A), D381.2 (A), D382.2 (A), D383.2 (A), D384.2 (A), D385.2 (A), D386.2 (A), R56.1
unnamed: D387.2 (A), D388.2 (A), D389.2 (A), D390.2 (A), D391.2 (A), D392.2 (A), D393.2 (A), D394.2 (A), D395.2 (A), D396.2 (A), D397.2 (A), D398.2 (A), D399.2 (A), D400.2 (A), D401.2 (A), R57.1
unnamed: D402.2 (A), D403.2 (A), D404.2 (A), D405.2 (A), D406.2 (A), D407.2 (A), D408.2 (A), D409.2 (A), D410.2 (A), D411.2 (A), D412.2 (A), D413.2 (A), D414.2 (A), D415.2 (A), D416.2 (A), R58.1
unnamed: D417.2 (A), D418.2 (A), D419.2 (A), D420.2 (A), D421.2 (A), D422.2 (A), D423.2 (A), D424.2 (A), D425.2 (A), D426.2 (A), D427.2 (A), D428.2 (A), D429.2 (A), D430.2 (A), D431.2 (A), R59.1
unnamed: D432.2 (A), D433.2 (A), D434.2 (A), D435.2 (A), D436.2 (A), D437.2 (A), D438.2 (A), D439.2 (A), D440.2 (A), D441.2 (A), D442.2 (A), D443.2 (A), D444.2 (A), D445.2 (A), D446.2 (A), R60.1
unnamed: D447.2 (A), D448.2 (A), D449.2 (A), D450.2 (A), D451.2 (A), D452.2 (A), D453.2 (A), D454.2 (A), D455.2 (A), D456.2 (A), D457.2 (A), D458.2 (A), D459.2 (A), D460.2 (A), D461.2 (A), R61.1

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
Board: 4 copper layers, 223.5 x 156.2 mm, 549 parts (0 on the bottom side), 138 nets.

## Commit log

2019-08-01 Replace micro QR code with a standard QR code
2019-08-01 Add Octave exploring QR code solutions
2019-08-01 Show diff against correct image
2019-08-01 Initial commit
    There will be many others
    But this one is first
2019-08-01 Generate data pixels from convoluted Boolean expressions
2019-08-01 Scramble solution vector
2019-08-01 Add functions for simulating shift registers
2019-08-01 Add function for simulating sequence of outputs
2019-08-01 Remove unused parameter
2019-08-01 Add function animate_shift_registers
2019-08-01 Add brute force solution counter function
2019-08-01 Scramble pixel groups with XORs of only 2 inputs
    This will greatly simplify the circuits since XOR circuits typically
    come in sets of 2-input gates.
2019-08-01 Add first draft of circuit schematic
2019-08-01 Add footprint for push button
2019-08-01 Add MTS-102-A2 switch footprint
2019-08-01 Clean up circuit draft
2019-08-01 WIP: schematic
2019-08-01 Update QR code to real flag
2019-08-01 Experiment with rearranging ICs
2019-08-01 Wire up all the logic
2019-08-01 Finish wiring up the logic
2019-08-01 Swap positions of LEDs and Rs in matrix
2019-08-01 Work on laying out the LED matrix
2019-08-01 Finish laying out the LEDs
2019-08-01 Move LED component references to F.Fab layer
2019-08-01 Add anode wires for matrix LEDs
2019-08-01 Move matrix R component references to F.Fab layer
2019-08-01 Wire up some of the matrix
2019-08-01 Add GND wires to LED matrix
2019-08-01 Add battery holders
2019-08-01 Add footprint for AA battery holder
2019-08-01 Finish wiring everything up
2019-08-01 Add coin cell battery holder
2019-08-01 Prettify signature box
2019-08-01 Re-annotate components
2019-08-01 Tidy up wires
2019-08-01 Restore mounting holes
2019-08-01 Do show the little lines on the silkscreen-less resistor footprint
2019-08-01 More finishing touches
2019-08-01 Add *.kicad_pcb-bak to gitignore
2019-08-01 Print schematic draft 3
2019-08-01 Fix tracks too close to vias
2019-08-01 Fix orientation of pads in MTS-102-A2 footprint
2019-08-01 Ignore .bak files
2019-08-01 Update footprints in schematic
2019-08-01 Add alignment markings to GPBS850L footprint
2019-08-01 Add mounting holes near the middle
2019-08-01 Fix errors in unpack_state
2019-08-01 Update PCB routes to agree with new schematic
2019-08-01 Add GND and VCC connections to ICs...
2019-08-01 Fix position of F.Fab label on MTS-102-A2 footprint
2019-08-01 Add debounce to SW1
2019-08-01 Rotate U5 footprint 180 degrees
2019-08-01 Rotate U15 footprint 180 degrees
2019-08-01 Fix polarity of push buttons
2019-08-01 Fix outline angle in battery holder footprint
2019-08-01 Rotate U16 footprint 180 degrees
2019-08-01 Prettify axes in state machine animation
2019-08-01 Run tracks and vias cleanup
2019-08-01 Remove unused user input from state
2019-08-01 Fix polarity of SW3
2019-08-01 Remove unused toggle_user_input function
2019-08-01 Re-prettify state visualisation
2019-08-01 Remove useless x ticks
2019-08-02 Add link to build log
